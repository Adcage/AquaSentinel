# Repository Adcage/AquaSentinel

File README.md:

# AquaSentinel

<p align="left">

</p>

<p align="left">

</p>

<p align="left">

</p>

AquaSentinel 是面向泳池、游泳馆和水上场馆的实时 AI 安全监控系统。系统围绕“视频采集、AI 检测、告警生成、实时推送、现场处置、记录追踪”构建完整闭环，用于降低水域安全监控中的发现延迟、告警分发延迟和处置追踪成本。

## 核心亮点

| 亮点 | 说明 |
| --- | --- |
| 端到端安全监控闭环 | 从摄像头或 ESP32-CAM 视频采集开始，经过 AI 检测、告警落库、Web/Android 实时推送，最终进入确认、派发、处置和记录追踪流程。 |
| 视频网关与业务系统解耦 | `video-hub-service` 独立承担 RTSP、HTTP-MJPEG、HTTP-FLV、WebRTC、ESP32 WebSocket 推帧等视频接入和分发能力，Backend 聚焦权限、配置和业务编排。 |
| AI 检测与跟踪链路 | `yolo-service` 基于 YOLOv8 执行人体目标检测，结合 DeepSort 多目标跟踪和溺水规则判定，输出结构化检测事件和风险信息。 |
| 多端实时协同 | Backend 统一接收 AI 推送并进行告警落库、状态管理和权限过滤，再通过 WebSocket 分发给 Web 管理后台与 Android 救生员端。 |
| 软硬件联动 | ESP32-CAM 负责摄像头采集、网络推帧和 HTTP 控制入口，STM32 负责双轴云台、OLED 状态展示、按键交互、电池采样和校准参数保存。 |
| 工程化治理 | 系统包含 JWT 鉴权、注解式权限控制、HMAC AI 回调校验、RabbitMQ 异步告警扩展、Prometheus 指标、OpenAPI 类型生成和统一响应信封。 |

## 效果展示

### 系统架构

### 视频链路

## 系统架构

系统按职责拆分为多个可独立运行的子项目：

| 模块 | 技术栈 | 核心职责 |
| --- | --- | --- |
| `backend` | Java 17 / Spring Boot / MyBatis-Plus / MySQL / Redis / WebSocket | 用户认证、权限控制、设备管理、告警落库、统计聚合、实时推送、业务 API |
| `frontend` | Vue 3 / TypeScript / Vite / Pinia / Element Plus / ECharts | Web 管理后台、设备监控、告警处置、数据看板、地图展示、AI 助手入口 |
| `yolo-service` | Python / Flask / YOLOv8 / DeepSort / OpenCV / PyAV | 视频流推理、目标检测、轨迹跟踪、溺水规则判定、AI 结果推送 |
| `video-hub-service` | Python / Flask / PyAV / aiortc / Redis Pub/Sub | 视频源接入、帧缓存、协议适配、MJPEG/Snapshot/WebRTC 分发 |
| `android` | Kotlin / Jetpack Compose / Retrofit / OkHttp / Media3 | 救生员移动端、实时告警接收、视频预览、现场处置、定位能力 |
| `firmware` | STM32 / ESP32-CAM / PlatformIO | 摄像头采集、云台控制、OLED 显示、设备侧交互和串口协议 |

详细架构说明见 [系统架构文档](docs/architecture/system-architecture.md)。

## 核心业务链路

### 视频接入与预览

摄像头、ESP32-CAM 或 RTSP 源输出视频后，由 `video-hub-service` 负责统一接入和协议适配。客户端不直接依赖底层视频源地址，而是通过 Backend 编排后的预览入口获取可播放的视频流。

```text
摄像头 / ESP32-CAM / RTSP 源
  -> video-hub-service
  -> MJPEG / Snapshot / WebRTC / 预览地址
  -> Frontend / Android
```

### AI 推理与溺水判定

`yolo-service` 读取视频帧后执行 YOLOv8 目标检测，通过 DeepSort 为目标分配稳定轨迹，再由规则服务根据持续时间、目标状态和位置变化判断风险。

```text
视频帧
  -> YOLOv8 人体检测
  -> DeepSort 多目标跟踪
  -> 溺水规则判定
  -> 检测事件 / 告警候选
```

### 实时告警分发

AI 服务通过 WebSocket 将检测结果推送到 Backend。Backend 统一进行告警记录、状态维护、权限过滤和多端分发，保证 Web 管理后台和 Android 端看到一致的告警状态。

```text
YOLO Service
  -> WebSocket
Backend
  -> 落库 + 状态管理 + 权限过滤
Frontend 管理后台 / Android 救生员端
  -> 确认、派发、处置、追踪
```

## 技术难点与设计取舍

### 视频流能力独立部署

视频预览如果直接放在 Backend 中处理，会让业务服务同时承担鉴权、CRUD、告警、转码和媒体分发职责。项目将视频流能力拆分到 `video-hub-service`，让 Backend 只负责配置、权限、路由和业务编排，视频网关负责拉流、缓存、协议适配和预览分发。

### 持续推理任务管理

AI 检测不是一次性模型调用，而是持续运行的视频任务。`yolo-service` 对推理任务进行启动、运行、停止、异常等状态管理，并配套读帧、推理、推帧和状态维护逻辑，以适配长时间监控场景。

### WebSocket 分层推送

告警链路同时涉及 AI 服务、业务后端、Web 管理端和 Android 端。项目将 AI 结果接入与用户端告警分发拆为不同 WebSocket 通道，避免前端直接依赖 AI 服务，也让 Backend 可以统一处理告警状态、权限过滤和多端同步。

### 接口一致性与类型安全

后端通过 Knife4j/OpenAPI 暴露接口规范，前端使用 openapi2ts 生成 API 调用代码和类型定义。业务页面通过 `services/` 层消费生成接口，减少手写请求造成的字段不一致、路径漂移和响应结构误用。

### 多端与硬件协同

Web 管理端适合场馆、设备、地图和统计管理，Android 端适合救生员现场接收和处置告警，硬件端负责视频采集与云台动作。系统通过统一 Backend 聚合设备、告警和处置状态，避免各端维护割裂的数据副本。

## 功能模块

| 模块 | 功能 |
| --- | --- |
| 用户与权限 | 登录注册、JWT 鉴权、刷新令牌、角色权限、接口级权限校验 |
| 场馆管理 | 场馆、区域、摄像头、救生员等基础数据维护 |
| 视频监控 | 摄像头列表、实时预览、视频流路由、云台控制入口 |
| AI 检测 | 推理任务管理、检测结果上报、溺水规则判定 |
| 告警中心 | 告警生成、实时推送、确认、派发、处置、记录追踪 |
| 数据看板 | 告警统计、设备状态、场馆态势、图表展示 |
| 移动端 | 救生员登录、告警接收、视频查看、定位与现场处置 |
| 硬件联动 | ESP32-CAM 视频采集、STM32 云台控制、OLED 信息显示、电池状态采样 |

## 技术栈

| 层级 | 技术 |
| --- | --- |
| Backend | Java 17 / Spring Boot 3.2.3 / MyBatis-Plus 3.5.5 / MySQL / Redis / JWT / WebSocket / RabbitMQ / Spring AI / Knife4j |
| Frontend | Vue 3 / TypeScript / Vite 7 / Pinia / Element Plus / ECharts / 高德地图 / openapi2ts |
| YOLO Service | Python / Flask / Flask-Smorest / SQLAlchemy / YOLOv8 / DeepSort / OpenCV / PyAV |
| Video Hub | Python / Flask / PyAV / aiortc / Redis Pub/Sub / MJPEG / Snapshot / WebRTC |
| Android | Kotlin / Jetpack Compose / Retrofit / OkHttp / Media3 ExoPlayer / Paging 3 / 高德 3D Map SDK |
| Firmware | STM32 / ESP32-CAM / PlatformIO / OLED / UART / PWM 云台控制 / KiCad |

完整技术栈说明见 [技术栈说明](docs/architecture/tech-stack.md)。

## 快速开始

### Docker Compose 启动核心服务

```bash
docker compose up -d
```

### 验证核心服务状态

```bash
pwsh ./scripts/verify_core_stack.ps1
```

详细启动步骤见 [核心服务启动指南](docs/deployment/core-stack-quickstart.md)。

## 本地开发命令

### Backend

```bash
cd backend
mvn compile
mvn test
```

### Frontend

```bash
cd frontend
npm install
npm run dev
npm run build
```

### YOLO Service

```bash
cd yolo-service
pip install -r requirements.txt
python main.py --dev
pytest
```

### Android

```bash
cd android
./gradlew assembleDebug
./gradlew test
```

## 仓库结构

```text
AquaSentinel/
├── backend/              # Spring Boot 业务后端
├── frontend/             # Vue 3 管理后台
├── yolo-service/         # Flask + YOLOv8 AI 推理服务
├── video-hub-service/    # 视频流接入与协议适配服务
├── android/              # Jetpack Compose 移动端
├── firmware/             # STM32 / ESP32-CAM 硬件端代码
├── docs/                 # 架构、部署、硬件、排障和归档文档
├── scripts/              # 启动、验证和辅助脚本
└── docker-compose.yml    # 核心服务编排
```

## 文档导航

| 分类 | 文档 | 说明 |
| --- | --- | --- |
| 系统架构 | [系统架构文档](docs/architecture/system-architecture.md) | 说明系统分层、服务职责、核心数据流和关键模块设计 |
| 技术栈 | [技术栈说明](docs/architecture/tech-stack.md) | 说明后端、前端、AI 服务、视频网关、Android 和硬件端的技术选型 |
| 快速启动 | [核心服务启动指南](docs/deployment/core-stack-quickstart.md) | 说明 Backend、YOLO Service、video-hub-service、MySQL、Redis 的本地启动方式 |
| 硬件设计 | [硬件设计说明](docs/hardware/hardware-design-spec.md) | 说明 ESP32-CAM、STM32、云台、供电和通信链路设计 |
| 硬件接线 | [硬件接线指南](docs/hardware/wiring-guide.md) | 说明 ESP32-CAM、STM32、舵机、OLED、按键和电源的接线方式 |
| 云台控制 | [STM32 云台控制说明](docs/hardware/stm32-ptz-guide.md) | 说明 STM32 云台控制器、串口协议、OLED 状态和电池检测能力 |

## KiCad design firmware/hardware/aquasentinel-hardware.kicad_pcb

Parts:
C1: 470uF/10V optional; CP_Radial_D10.0mm_P5.00mm
C2: 100uF/10V optional; CP_Radial_D6.3mm_P2.50mm
J1: 5V_BOOST_OUT; PinHeader_1x02_P2.54mm_Vertical
J2: 1S_LIION_BAT; PinHeader_1x02_P2.54mm_Vertical
J3: BAT_LEVEL_LED; PinHeader_1x02_P2.54mm_Vertical
J4: ESP32-CAM; ESP32_CAM_AI_Thinker_2x08_P22.86mm_Vertical_Labeled
J5: STM32F103C8T6_BLUEPILL; STM32_BluePill_2x20_P17.78mm_Vertical_Labeled
J6: SERVO_PAN_SG90; PinHeader_1x03_P2.54mm_Vertical
J7: SERVO_TILT_SG90; PinHeader_1x03_P2.54mm_Vertical
J8: SSD1306_OLED_I2C; PinHeader_1x04_P2.54mm_Vertical
R1, R2: 100k optional; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: USER_HOME_CALIB; SW_PUSH_6mm_2Pin_LR

Connections:
/BATT_POS: J2.1, J3.1, R1.2
/BAT_SENSE: J5.9 (PA0_/_ADC_IN0), R1.1, R2.2
/BTN_USER: J5.40 (PB12), SW1.1
/GND: C1.2 (-), C2.2 (-), J1.2, J2.2, J3.2, J4.3 (GND), J5.4 (GND), J5.37 (GND), J6.2, J7.2, J8.2, R2.1, SW1.2
/I2C_SCL: J5.14 (PB6_/_I2C1_SCL), J8.3
/I2C_SDA: J5.12 (PB7_/_I2C1_SDA), J8.4
/SERVO_PAN: J5.21 (PA6_/_TIM3_CH1), J6.3
/SERVO_TILT: J5.23 (PA7_/_TIM3_CH2), J7.3
/UART_ESP_RX: J4.11 (IO14), J5.30 (PA9_/_USART1_TX)
/UART_ESP_TX: J4.7 (IO13), J5.28 (PA10_/_USART1_RX)
/VCC_3V3: J5.2 (3V3), J8.1
/VCC_5V: C1.1 (+), C2.1 (+), J1.1, J4.1 (5V), J5.6 (5V), J6.1, J7.1

Notes on the sheet:
中文说明
说明: J4/J5 封装按真实模块双排排针近似, 原理图仅展开当前使用引脚
用户交互区
电源区
显示区
电池采样区
AquaSentinel ESP32-CAM + STM32F103C8T6 module wiring schematic
信号: UART_ESP_TX/RX 为串口通信, I2C_SCL/SDA 为显示总线
主控通信区
信号: VCC_5V=5V电源, VCC_3V3=3.3V电源, GND=系统地
模块: J1升压输出, J2锂电池, J3电量显示, J4 ESP32-CAM, J5 STM32控制板
采样: R1/R2 为电池分压采样, C1/C2 为电源稳压可选件
Optional parts: C1/C2 improve power stability; R1/R2 are for STM32 battery ADC. They can be omitted during functional verification.
信号: SERVO_PAN/TILT 为舵机PWM, BTN_USER 为按键, BAT_SENSE 为电池采样点
Same named labels are electrically connected. Every pin has a visible wire stub or direct wire.
执行器区
模块: J6水平舵机, J7俯仰舵机, J8 OLED显示, SW1用户按键

Board: 2 copper layers, 13 parts (0 on the bottom side), 12 nets.

## Commit log (part)

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2026-04-22 chore(git): 初始化仓库忽略规则
2026-04-22 feat(frontend): 导入MVP前端工程
2026-04-22 feat(android): 导入MVP安卓客户端
2026-04-22 refactor(backend): 统一数据库标识为aqua_sentinel
2026-04-22 chore(yolo): 将现有模型文件转为LFS对象
2026-04-22 docs: 删除过时的 mock 与计划文档
2026-04-23 feat(backend): 接入RabbitMQ报警消费链路与Prometheus指标
2026-04-23 chore(style): 引入Checkstyle并统一后端代码格式
2026-04-25 fix(messaging): 修复RabbitMQ消费反序列化并对齐队列声明
2026-04-25 docs(messaging): 补充报警事件消息模型字段注释
2026-04-25 chore(monitoring): 移除未使用的监控编排配置
2026-04-27 docs(hardware): 补充硬件设计说明文档
2026-04-27 feat(firmware): 初始化stm32-ptz PlatformIO工程
2026-04-27 feat(hardware): 新增AquaSentinel KiCad硬件工程
2026-04-27 feat(resilience): 添加Resilience4j容错依赖和配置
    - pom.xml: 新增 resilience4j-spring-boot3:2.2.0、bucket4j-core:8.10.1、bucket4j-redis:8.10.1、redisson-spring-boot-starter:3.27.2
    - application.yml: 新增 resilience4j 配置节（circuitbreaker/retry/timelimiter/ratelimiter），redisson 单节点配置，app.rate-limit 限流配置
2026-04-27 feat(resilience): 为AiEngineClient添加熔断器和重试注解及降级方法
2026-04-27 feat(ratelimit): 为控制器添加限流注解，重构报警推送异常隔离
2026-05-02 feat(backend-ai-chat): 新增 AI 会话消息模型与接口
2026-05-02 feat(backend-ai-func): 增加函数调用代理与业务查询函数
2026-05-02 feat(backend-device): 新增摄像头批量禁用接口与服务实现
2026-05-02 feat(frontend-ai): 增加 AI 助手页面侧边栏入口与聊天服务
2026-05-02 refactor(frontend-admin): 清理管理端无效逻辑与兼容性细节
2026-05-02 docs(planning): 补充阶段实现与硬件引脚对照文档
2026-05-02 feat(backend-device): 新增摄像头批量删除接口
2026-05-04 feat(backend): 新增云台 PTZ 控制功能
    - 新增 CameraPtzControlRequest DTO，支持 NUDGE/HOME/STATUS/CALIB_* 等动作
    - 新增 Esp32PtzControlService，通过 HTTP 请求向 ESP32-CAM 设备下发控制指令
    - CameraDeviceController 新增 POST /cameras/control/ptz 端点，仅限场馆管理员调用
2026-05-04 refactor(firmware): ESP32-CAM 模块化重构
    - 将 main.cpp 中的视频流和 HTTP 服务重构为独立模块：CameraStreamer、ControlServer
    - 新增 UartBridge 用于 ESP32 与 STM32 之间 UART 通信
    - 配置统一管理（config.h）：WiFi、UART、视频流参数
    - 协议头文件（protocol.h）定义通信格式
2026-05-04 refactor(firmware): STM32-PTZ 云台控制模块化重构
    - 重构 main.cpp，使用 PtzServo、UartHandler 管理舵机与串口通信
    - 新增 CalibStorage 校准数据持久化管理
    - 配置统一管理（config.h）：UART、舵机引脚、角度限位
    - 协议头文件（protocol.h）定义与 ESP32 通信格式
2026-05-05 refactor(firmware): 重构云台控制与校准协议
2026-05-05 docs: 补充云台接线说明
2026-05-08 docs: 澄清电池采样与双开关接线关系
2026-05-08 docs(firmware): 新增 PB12 与 OLED 交互实施计划
2026-05-08 docs(firmware): 新增 STM32 PTZ 交接状态文档
2026-05-09 chore: 添加 *.exe 到 .gitignore 并清理调试编译产物
2026-05-12 docs(firmware): 更新 STM32 PTZ 交接文档，修正未提交文件描述并补充测试状态说明
2026-05-13 feat(firmware): ESP32-CAM 迁移到异步 WebServer 与非阻塞 MJPEG 推流
    - WebServer 替换为 ESPAsyncWebServer + AsyncTCP，消除阻塞式轮询
    - 新增 fillStreamChunk() 分块推流，支持异步 chunked 响应
    - 单客户端限制(MAX_STREAM_CLIENTS=1)与 30s 超时保护
    - 恢复摄像头初始化，分辨率降为 QVGA，帧间隔提至 120ms
    - 所有 API 路由重写为 AsyncWebServer 回调风格
2026-05-13 feat(yolo): 引擎推理循环接入 video_hub 拉流并提取公共辅助函数
    - 新增 _run_loop_with_video_hub() 从 FrameCache 取帧解码推推理
    - 提取 _build_tracker() / _build_drowning_evaluator() 消除三处重复
    - 新增 _should_use_video_hub_for_stream() 自动路由 HTTP 流到 video_hub
    - 推送报文新增 frameWidth/frameHeight/frameTs 字段
    - 附带 video_hub 推理链路测试
2026-05-13 feat(frontend): 新增 LogoIcon 组件替换侧栏与登录页品牌展示
    - 新增 LogoIcon.vue 组件(引用 /logo.svg, 支持 size prop)
    - 登录页左侧品牌区域新增 LogoIcon + 白色勾边 drop-shadow
    - 侧栏折叠态以 LogoIcon 替换原文字方块占位
    - favicon 从 .ico 切换为 .png 格式
2026-05-13 feat(backend): VO 增加 previewUrl/deviceBaseUrl，Service 层填充平台预览地址
    - CameraDeviceVO 新增 previewUrl、deviceBaseUrl 字段
    - CameraPreviewRouteService 新增 buildPreviewUrl() 返回平台预览路径，
    buildDeviceBaseUrl() 从 streamUrl 提取设备基地址
    - CameraDeviceServiceImpl.getCameraDeviceVO() 填充两个字段
    - Esp32PtzControlService.resolveDeviceBaseUrl() 补充约束注释：
    PTZ 必须指向设备本体，不可误用平台预览地址
2026-05-13 feat(frontend): 视频流改走后端平台预览地址，resolveBackendProxyUrl 正确拼接 API 前缀与 token
    - streamPreview.ts: resolveBackendProxyUrl 接收 previewUrl 参数，
    相对路径自动拼接 VITE_API_BASE_URL 前缀与 token，
    绝对 URL 直接使用并追加 token
    - business.ts: DeviceRecord 新增 previewUrl、deviceBaseUrl 可选字段
    - dashboardService.ts: 传递 previewUrl 给 resolveCameraPreviewTarget
    - deviceService.ts: 映射 previewUrl/deviceBaseUrl 并扩展 VO 类型
2026-05-13 test: 补充 previewUrl/deviceBaseUrl 及流解析相关单元测试
    - CameraPreviewRouteServiceTest: 新增 buildPreviewUrl、buildDeviceBaseUrl、
    getCameraDeviceVO 包含预览地址的测试
    - Esp32PtzControlServiceTest: 新增 PTZ 设备基地址解析测试
    - streamPreview.test.ts: 新增相对路径拼接 API 前缀、绝对 URL 直接使用测试
    - test_video_hub_frame_consumer.py: YOLO 推理从 video_hub 取帧回归测试
2026-05-13 docs: 更新 ESP32-CAM 视频分发实施计划，调整阶段一与阶段二的边界和模块边界
2026-05-14 feat(yolo): video_hub 拉流健壮性改造——四态状态机、退避策略、熔断、无帧超时、管理接口
    - frame_cache 新增 last_frame_at 字段用于无帧超时检测
    - source_worker 引入 SessionState 四态枚举（CONNECTING/CONNECTED/STALE/CIRCUIT_OPEN）
    - 退避策略：1-2次1.5s → 3-4次3s → 5-6次5s → 7-9次10s → ≥10次60s熔断探测
    - 无帧超时：stale_frame_timeout_sec=5.0，超时进入STALE立即重连
    - 熔断：连续失败≥10次进入CIRCUIT_OPEN，60s低频探测，ensure/reconnect可激活跳出
    - registry 新增 remove_session()，调用 session.stop() 后移除会话
2026-05-14 refactor(yolo): 默认关闭服务端叠框，改为前端叠框（OVERLAY_SERVER_SIDE_ENABLED 开关）
2026-05-14 refactor(frontend): CameraGridCard 叠框抽为 CameraOverlayLayer 独立组件
    - 删除内联叠框 div 和 toBoxStyle/toDisplayLabel/toPercent 方法
    - 接入 CameraOverlayLayer 组件，传入 detections + 帧尺寸 + 显示尺寸
    - 新增 ResizeObserver 监听视频容器尺寸
    - 叠框层在三种协议之上统一覆盖
2026-05-14 docs: 添加阶段二设计 spec 与实施计划
2026-05-15 refactor(yolo): 移除 video_hub 内置模块，改用 HTTP 客户端对接独立 video-hub-service
    - 删除 yolo-service 内置的 video_hub 包（registry、source_worker、frame_cache、webrtc_session、webrtc_signaling）及其 API 蓝图
    - 新增 VideoHubClient HTTP 客户端，通过 REST 调用独立 video-hub-service 的 ensure/snapshot/status/reconnect 端点
    - engine_task_service 改用 video_hub_client.fetch_snapshot() 替代 frame_cache.wait_for_frame()，帧时间戳改用本地 time.time()
    - BaseConfig 新增 VIDEO_HUB_BASE_URL / VIDEO_HUB_TIMEOUT_MS 配置项
    - 重构 test_video_hub_frame_consumer 适配 FakeVideoHubClient，新增 URL 构建测试
    - 删除不再需要的 5
2026-05-15 test(backend): 适配 VideoHub 配置抽离后的单元测试
    - VideoHubProxyControllerTest 改用 AppVideoHubProperties mock，baseUrl 从 5000 改为 5100
    - 新增 CameraDeviceService mock，WHIP 测试验证 source_url 参数传递
    - rest template exchange 参数从 String 改为 URI 匹配
    - CameraPreviewRouteServiceTest 同步切换到 AppVideoHubProperties，期望 URL 端口更新为 5100
2026-05-15 feat(yolo): 新增 VIDEO_HUB_BASE_URL 和 VIDEO_HUB_TIMEOUT_MS 环境变量配置到 .env.example
2026-05-15 docs: 添加 video-hub-service 解耦计划、WebRTC mDNS ICE 修复设计与固件文档
    - docs/firmware/stm32-ptz-guide.md: STM32 PTZ 控制指南
    - docs/superpowers/plans: video-hub-service 解耦实施计划、WebRTC mDNS ICE 修复计划
    - docs/superpowers/specs: 全局 MJPEG 预览设计 spec、WebRTC mDNS ICE 修复设计 spec
    - docs/规划文档/video-hub-service-decoupling-plan.md: 解耦总规划文档
2026-05-15 feat(backend): 将 WHIP 代理改为 token 校验与摄像头视频源解析接口
    - 移除 WHIP 代理转发逻辑，新增 GET /video-hub/auth/verify-preview-token 校验预览令牌
    - 新增 GET /video-hub/auth/camera-source 根据 cameraId 返回视频源地址
    - DELETE /sessions/{sessionId} 保留但不再代理转发
    - 移除 AppVideoHubProperties / HttpClient / RestTemplate 依赖
    - 重写单元测试覆盖新接口
2026-05-15 test(video-hub-service): 新增 camera_source_resolver 与 WHIP 集成 token 校验的测试
    - 新增 test_camera_source_resolver 覆盖缺失 token、正常解析、非 200 响应场景
    - 更新 test_video_hub_webrtc 适配 WHIP 端点 token 校验与 camera_source_resolver 调用
2026-05-15 feat(frontend): WebRTC 直连架构，token 改用 Authorization header 传递，新增调试日志控制
    - streamPreview.ts 移除 query 参数拼 token 逻辑，webrtc URL 不再泄露 token 和 source_url
    - WebRtcWhepPlayer.vue 发送 WHIP 请求时从 sessionStorage 读取 token 放入 Authorization header
    - 新增 webrtcDebug.ts 工具模块，支持 VITE_WEBRTC_DEBUG_VERBOSE 开关控制日志详细度
    - 非详细模式下仅输出关键状态变更日志，stats 轮询输出精简摘要
    - 新增 webrtcDebug.test.ts 和 streamPreview 补充测试
2026-05-15 docs: 添加 WebRTC 直连架构实施计划与排障总结文档
2026-05-16 feat(backend): 新增 CameraStreamSyncService，摄像头 CRUD 集成 Redis 流同步
    - 新增 CameraStreamSyncService：通过 Redis Hash + Pub/Sub 将摄像头配置同步到 video-hub
    - upsertCameraStream：启用且有合法流URL的摄像头写入 Redis 并发布事件
    - removeCameraStream：禁用/删除摄像头时从 Redis 删除并发布事件
    - initialSync：应用启动时全量同步已启用的摄像头到 Redis
    - 仅支持 rtsp://, http://, https:// 协议的流URL
    - CameraDeviceController 各增删改端点集成 streamSync 调用
2026-05-16 fix(yolo): 修复 .env 加载与测试隔离问题
    - create_app() 非测试环境调用 load_dotenv(override=False)，解决 MODEL_VERSION_PATHS 为空的问题
    - 新增 python-dotenv 依赖
    - test_docs_delivery：移除 WECHAT_APP_ID 断言，改为检查 VIDEO_HUB_BASE_URL 和 MODEL_VERSION_PATHS_JSON
    - test_model_inference_service：monkeypatch 移至 create_app 之前，确保 warmup_model 使用 fake YOLO；
    新增 autouse fixture 清理 _MODEL_INSTANCES 等模块缓存，消除跨测试状态污染
    - test_stream_worker_service：重写为 video-hub 路由测试 FakeVideoHubClient
2026-05-16 docs: 新增核心链路快速启动文档
    覆盖 MySQL/Redis/Backend/video-hub/YOLO 五个服务的环境要求、配置入口、
    启动顺序、健康检查验证步骤及已知限制说明。
2026-05-16 docs: 补充部署方式说明，明确当前采用手动启动方案
2026-05-16 docs: 回填首页运行入口、指标摘要链接与文档导航
2026-05-16 build: 新增全部 Dockerfile 与 docker-compose.yml，一键启动核心服务栈
    - backend: 多阶段构建 Maven + JRE 17
    - yolo-service: Python 3.12 + OpenCV 系统依赖 + model 卷挂载
    - video-hub-service: Python 3.12 轻镜像
    - frontend: 多阶段构建 npm + nginx 反向代理 Backend API/WS
    - docker-compose: MySQL 8 + Redis 7 + Backend + video-hub + YOLO + Frontend
    - 各服务 .dockerignore 排除无关文件
2026-05-16 feat(backend): 视频预览路由与代理接口支持 rotation 参数透传
    - CameraPreviewRouteService 构建 stream URL 时追加 rotation 查询参数
    - VideoHubProxyController 获取源地址接口返回 rotation 值
2026-05-16 test(video-hub): 适配 rotation 参数的测试用例更新
    - FakeRegistry/DummySession/Stub* 的 ensure_session 签名统一添加 rotation 参数
    - DummySession 保存 rotation 属性
2026-05-16 chore: Docker/Nginx 配置优化与部署参数补全
    - backend Dockerfile 构建时跳过 spotless/checkstyle 检查
    - frontend Dockerfile 改用 npm install 替代 npm ci 兼容 lock 版本差异
    - nginx.conf 抽取 upstream、WebSocket 路由优先、增加 read_timeout
    - docker-compose 补充 AI 引擎与回调 URL 环境变量、yolo RABBITMQ_URL 占位
    - 两个 .dockerignore 新增 .env 屏蔽
    - yolo config 新增 JAVA_BACKEND_BASE_URL 环境变量覆盖
2026-05-16 feat(firmware): STM32 OLED 新增网络页显示 ESP32 IP 地址
    - 两端 protocol.h 新增 IP: 命令常量
    - ESP32 WiFi 连接成功后通过 UART 推送 IP 地址
    - STM32 UartHandler 识别 IP: 前缀并存储到全局缓冲区
    - OLED 新增 Network 页面，短按 PB12 切换显示
    - 新增网、络中文字模及 F、K ASCII 字模
    - hasStateChanged 检测 IP 变化即时刷新
2026-05-17 feat(video-hub): WebSocket 推帧接入与推流模式支持
    - 新增 /video-hub/cameras/push WebSocket 端点，接收 ESP32 推送的 JPEG 帧
    - VideoHubSession 新增 stream_mode 字段（pull/push），push 模式跳过拉流循环
    - Registry 新增 get_or_create_session 与 switch_to_push_mode 方法
    - Redis 同步事件携带 stream_mode 字段透传
    - 新增 MediaPortPool 管理可配置的 WebRTC 媒体端口范围，patch aioice 端口分配
    - 新增 VIDEO_HUB_PUSH_TOKEN 与 WEBRTC_MEDIA_PORT_RANGE 配置项
2026-05-17 feat(video-hub): WebRTC SDP 答复私有 IP 重写与 c= 行修正
    - _pin_answer_candidates 新增私有 IPv4 地址重写逻辑：非 preferred 的内网地址统一替换为 fallback_ip
    - 新增 c=IN IP4 行重写：将内网 IP 替换为 fallback_ip，确保浏览器正确路由媒体流
    - 新增 _is_private_ipv4 辅助函数识别 10.x / 172.16-31.x / 192.168.x 网段
    - 日志新增 rewritten 计数
2026-05-17 feat(backend): 新增 WebRTC 配置端点返回 preferredIp
    - VideoHubProxyController 新增 GET /webrtc-config 接口，返回 AppVideoHubProperties 中的 preferredIp
    - 前端可通过此接口运行时获取 WebRTC ICE 候选替换 IP，无需构建时配置
    - 新增单元测试验证 preferredIp 有值/为空两种场景
2026-05-17 feat(frontend): WebRTC ICE 候选 IP 运行时获取服务
    - 新增 webrtcConfigService：优先从后端 /api/video-hub/webrtc-config 获取 preferredIp，降级使用 VITE_WEBRTC_CANDIDATE_IPS 环境变量
    - 内置单次 fetch + 缓存机制，避免重复请求
    - WebRtcWhepPlayer 发送 offer 前自动调用 fetchWebrtcCandidateIps 替换 mDNS 候选
    - streamPreview.ts 将 resolveWebrtcCandidateIps 改为从 webrtcConfigService 重导出
    - 移除 streamPreview.test.ts 中旧的 env 解析测试，新增 webrtcConfigService 完整测试
    - .env.example 更新注释说明生产/开发环境配置方式
2026-05-17 refactor(frontend): PTZ 测试页面布局重构
    - 视频预览区域从左侧 2/3 改为全宽独立卡片，背景改为黑色
    - 方向控制与校准操作改为左右两列等宽布局（各 md=12）
    - 移除 calibration-card 额外上边距与 min-height 约束
    - 视频预览 max-height 调整为 480px，占位区域增加 padding
2026-05-17 docs: 新增推帧/WebRTC配置/PTZ弹窗的设计文档与实施计划
2026-05-17 test(firmware): PTZ 梯形平滑器主机仿真测试
    - 纯 C++ 主机端仿真，验证梯形速度曲线核心算法
    - 测试全行程(500→2500us)、反向行程、小行程、零行程、死区边界、减速区行程
    - 断言收敛性、最大速度限制、减速行为和死区处理
2026-05-18 chore(scripts): 新增性能基准采集脚本
2026-05-18 feat: 新增视频链接示意图
2026-05-18 docs: 精简重写 README.md，更新文档导航链接
    - 重写项目简介，突出核心亮点和技术要点
    - 将项目特点列表改为核心亮点表格，更紧凑清晰
    - 更新文档导航链接指向新的英文分类目录
    - 移除冗余的分隔线和图片占位表格
    - 技术栈表格补充 RabbitMQ、Spring AI、openapi2ts 等遗漏项
    - 新增硬件设计、接线指南、故障排查等文档链接
2026-05-18 docs: 移除 DrawIO 接线图文件
